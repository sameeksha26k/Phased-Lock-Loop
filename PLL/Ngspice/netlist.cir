* C:\Users\My PC\Downloads\Spice64\bin\On-chip_PLL.asc
M1 Vdd Vdd N007 N001 p_mos
M2 Vdd Clk1 N006 N002 p_mos
M3 Vdd N006 Vdd N003 p_mos
M4 Vdd ~reset Vdd N004 p_mos
M5 Vdd Vdd Up N005 p_mos
M6 N007 Clk1 N009 N008 p_mos
M13 N006 N009 N012 N010 n_mos
M14 Vdd Clk1 N013 N011 n_mos
M15 N009 Vdd 0 N014 n_mos
M16 N012 Clk1 0 N016 n_mos
M17 N013 N006 0 N017 n_mos
M18 Up Vdd 0 N015 n_mos
M7 Vdd Vdd N024 N018 p_mos
M8 Vdd Clk2 N023 N019 p_mos
M9 Vdd N023 Vdd N020 p_mos
M10 Vdd ~reset Vdd N021 p_mos
M11 Vdd Vdd Down N022 p_mos
M12 N024 Clk2 N026 N025 p_mos
M19 N023 N026 N029 N027 n_mos
M20 Vdd Clk2 N030 N028 n_mos
M21 N026 Vdd 0 N031 n_mos
M22 N029 Clk2 0 N033 n_mos
M23 N030 N023 0 N034 n_mos
M24 Down Vdd 0 N032 n_mos
V1 Vdd 0 1.8
V2 Clk1 0 PULSE(0 1.8 0 100n 100n .1m .2m 500)
M25 Vdd Up ~reset N056 p_mos
M27 ~reset Up N065 N064 n_mos
M28 N065 Down 0 N071 n_mos
M29 Vdd N035 N035 N036 p_mos
M30 Vdd N035 N043 N041 p_mos
M31 Vdd N035 N044 N037 p_mos
M32 Vdd N035 N045 N038 p_mos
M33 Vdd N035 N046 N039 p_mos
M34 Vdd N035 N042 N040 p_mos
M35 N043 Clk2 N052 N047 p_mos
M36 N044 N052 N053 N051 p_mos
M37 N045 N053 N054 N048 p_mos
M38 N046 N054 N055 N049 p_mos
M39 N042 N055 Clk2 N050 p_mos
M40 N035 Vcont 0 N058 n_mos
M41 N052 Clk2 N070 N059 n_mos
M42 N053 N052 N066 N060 n_mos
M43 N054 N053 N067 N061 n_mos
M44 N055 N054 N068 N062 n_mos
M45 Clk2 N055 N069 N063 n_mos
M46 N070 Vcont 0 N076 n_mos
M47 N066 Vcont 0 N072 n_mos
M48 N067 Vcont 0 N073 n_mos
M49 N068 Vcont 0 N074 n_mos
M50 N069 Vcont 0 N075 n_mos
M52 N079 Down 0 N081 n_mos
C1 N079 0 10n
C2 N080 0 10n
R1 N080 N079 10k
M26 Vdd Down ~reset N057 p_mos
M51 Vdd Up N079 N078 p_mos
C3 N052 0 15p
C4 N053 0 15p
C5 N054 0 15p
C6 N055 0 15p
C7 Clk2 0 15p
*XU1 N080 N077 Vpos Vneg Vcont AD549
R2 N077 0 1k
R3 Vcont N077 99k
V3 Vpos 0 5
V4 Vneg 0 -5
.model NMOS NMOS
.model PMOS PMOS
*.lib C:\Users\My PC\OneDrive\Documents\LTspiceXVII\lib\cmp\standard.mos
* PHASE FREQUENCY DETECTOR
* CHARGE PUMP and LOW PASS FILTER
* VOLTAGE CONTROLLED RING OSCILLATOR
.model n_mos NMOS (LEVEL=8 VERSION=3.2 TNOM=27 TOX=4.1E-9 XJ=1E-7 NCH=2.3549E17 VTH0=0.3823463 K1=0.5810697
*+            K2=4.774618E-3 K3=0.0431669 K3B=1.1498346 W0=1E-7 NLX=1.910552E-7 DVT0W=0 DVT1W=0 DVT2W=0
*+            DVT0=1.2894824 DVT1=0.3622063 DVT2=0.0713729 U0=280.633249 UA=-1.208537E-9 UB=2.158625E-18
*+            UC=5.342807E-11 VSAT=9.366802E4 A0=1.7593146 AGS=0.3939741 B0=-6.413949E-9 B1=-1E-7 KETA=-5.180424E-4
*+            A1=0 A2=1 RDSW=105.5517558 PRWG=0.5 PRWB=-0.1998871 WR=1 WINT=7.904732E-10 LINT=1.571424E-8 XL=0
*+            XW=-1E-8 DWG=1.297221E-9 DWB=1.479041E-9 VOFF=-0.0955434 NFACTOR=2.4358891 CIT=0 CDSC=2.4E-4 CDSCD=0
*+            CDSCB=0 ETA0=3.104851E-3 ETAB=-2.512384E-5 DSUB=0.0167075 PCLM=0.8073191 PDIBLC1=0.1666161 PDIBLC2=3.112892E-3
*+            PDIBLCB=-0.1 DROUT=0.7875618 PSCBE1=8E10 PSCBE2=9.213635E-10 PVAG=3.85243E-3 DELTA=0.01 RSH=6.7 MOBMOD=1
*+            PRT=0 UTE=-1.5 KT1=-0.11 KT1L=0 KT2=0.022 UA1=4.31E-9 UB1=-7.61E-18 UC1=-5.6E-11 AT=3.3E4 WL=0 WLN=1
*+            WW=0 WWN=1 WWL=0 LL=0 LLN=1 LW=0 LWN=1 LWL=0 CAPMOD=2 XPART=0.5 CGDO=7.08E-10 CGSO=7.08E-10 CGBO=1E-12
*+            CJ=9.68858E-4 PB=0.8 MJ=0.3864502 CJSW=2.512138E-10 PBSW=0.809286 MJSW=0.1060414 CJSWG=3.3E-10 PBSWG=0.809286
*+            MJSWG=0.1060414 CF=0 PVTH0=-1.192722E-3 PRDSW=-5 PK2=6.450505E-5 WKETA=-4.27294E-4 LKETA=-0.0104078
*+            PU0=6.3268729 PUA=2.226552E-11 PUB=0 PVSAT=969.1480157 PETA0=1E-4 PKETA=-1.049509E-3)
.model p_mos PMOS (LEVEL=8 VERSION=3.2 TNOM=27 TOX=4.1E-9 XJ=1E-7 NCH=4.1589E17 VTH0=-0.3938813 K1=0.5479015
*+            K2=0.0360586 K3=0.0993095 K3B=5.7086622 W0=1E-6 NLX=1.313191E-7 DVT0W=0 DVT1W=0 DVT2W=0 DVT0=0.4911363
*+            DVT1=0.2227356 DVT2=0.1 U0=115.6852975 UA=1.505832E-9 UB=1E-21 UC=-1E-10 VSAT=1.329694E5 A0=1.7590478
*+            AGS=0.3641621 B0=3.427126E-7 B1=1.062928E-6 KETA=0.0134667 A1=0.6859506 A2=0.3506788 RDSW=168.5705677
*+            PRWG=0.5 PRWB=-0.4987371 WR=1 WINT=0 LINT=3.028832E-8 XL=0 XW=-1E-8 DWG=-2.349633E-8 DWB=-7.152486E-9
*+            VOFF=-0.0994037 NFACTOR=1.9424315 CIT=0 CDSC=2.4E-4 CDSCD=0 CDSCB=0 ETA0=0.0608072 ETAB=-0.0426148
*+            DSUB=0.7343015 PCLM=3.2579974 PDIBLC1=7.229527E-6 PDIBLC2=0.025389 PDIBLCB=-1E-3 DROUT=0 PSCBE1=1.454878E10
*+            PSCBE2=4.202027E-9 PVAG=15 DELTA=0.01 RSH=7.8 MOBMOD=1 PRT=0 UTE=-1.5 KT1=-0.11 KT1L=0 KT2=0.022 UA1=4.31E-9
*+            UB1=-7.61E-18 UC1=-5.6E-11 AT=3.3E4 WL=0 WLN=1 WW=0 WWN=1 WWL=0 LL=0 LLN=1 LW=0 LWN=1 LWL=0 CAPMOD=2 XPART=0.5
*+            CGDO=6.32E-10 CGSO=6.32E-10 CGBO=1E-12 CJ=1.172138E-3 PB=0.8421173 MJ=0.4109788 CJSW=2.242609E-10 PBSW=0.8            +            MJSW=0.3752089 CJSWG=4.22E-10 PBSWG=0.8 MJSWG=0.3752089 CF=0 PVTH0=1.888482E-3 PRDSW=11.5315407 PK2=1.559399E-3
*+            WKETA=0.0319301 LKETA=2.955547E-3 PU0=-1.1105313 PUA=-4.62102E-11 PUB=1E-21 PVSAT=50 PETA0=1E-4 PKETA=-4.346368E-3)
.TRAN 3.4v 360e-6s
* Amplifier
*.lib ADI1.lib
*.backanno
.end
